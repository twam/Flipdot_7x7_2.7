# Repository twam/Flipdot_7x7_2.7

## KiCad design Flipdot_7x7.kicad_pcb

Board: 2 copper layers, 71.5 x 71.5 mm, 128 parts (7 on the bottom side), 114 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56: PMBD7000; SOT-23
P1, P2: CONN_01X16; Pin_Header_Straight_1x16
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14: DMG6602SVT; SOT-23-6
Q15, Q16, Q17, Q18, Q19, Q20, Q21: DMN3190LDW; SC-70-6
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14: 22k; R_0603
R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42: 100k; R_0603
U1, U2, U3, U4, U5, U6, U7: FlipDot; AZXY5_2.7

Connections:
/CH0: D1.1, D8.3, D17.1, D25.1, D32.1, D41.1, D50.1, Q1.4
/CH1: D2.1, D10.1, D11.3, D18.1, D26.1, D33.1, D51.1, Q2.4
/CH2: D3.1, D12.1, D19.3, D27.1, D34.1, D43.1, D52.1, Q3.4
/CH3: D4.1, D13.1, D21.1, D28.1, D35.3, D44.1, D53.1, Q4.4
/CH4: D5.1, D14.1, D22.1, D29.1, D37.3, D45.1, D54.1, Q5.4
/CH5: D6.1, D15.1, D23.1, D30.1, D39.1, D46.3, D55.1, Q6.4
/CH6: D7.1, D16.1, D24.1, D31.1, D40.1, D48.3, D56.1, Q7.4
/CHI0: P1.1, Q1.1, R15.1
/CHI1: P1.2, Q2.1, R16.1
/CHI2: P1.3, Q3.1, R17.1
/CHI3: P1.4, Q4.1, R18.1
/CHI4: P1.5, Q5.1, R19.1
/CHI5: P1.6, Q6.1, R20.1
/CHI6: P1.7, Q7.1, R21.1
/CL0: D1.2, D9.3, D17.2, D25.2, D32.2, D41.2, D50.2, Q15.6
/CL1: D2.2, D10.2, D18.2, D26.2, D33.2, D42.3, D51.2, Q15.3
/CL2: D3.2, D12.2, D20.3, D27.2, D34.2, D43.2, D52.2, Q16.6
/CL3: D4.2, D13.2, D21.2, D28.2, D36.3, D44.2, D53.2, Q16.3
/CL4: D5.2, D14.2, D22.2, D29.2, D38.3, D45.2, D54.2, Q17.6
/CL5: D6.2, D15.2, D23.2, D30.2, D39.2, D47.3, D55.2, Q17.3
/CL6: D7.2, D16.2, D24.2, D31.2, D40.2, D49.3, D56.2, Q18.6
/CLI0: P2.1, Q15.2, R29.1
/CLI1: P2.2, Q15.5, R30.1
/CLI2: P2.3, Q16.2, R31.1
/CLI3: P2.4, Q16.5, R32.1
/CLI4: P2.5, Q17.2, R33.1
/CLI5: P2.6, Q17.5, R34.1
/CLI6: P2.7, Q18.2, R35.1
/LS0: Q8.4, Q18.3, U1.8, U1.9, U1.10, U1.11, U1.12, U1.13, U1.14
/LS1: Q9.4, Q19.6, U2.8, U2.9, U2.10, U2.11, U2.12, U2.13, U2.14
/LS2: Q10.4, Q19.3, U3.8, U3.9, U3.10, U3.11, U3.12, U3.13, U3.14
/LS3: Q11.4, Q20.6, U4.8, U4.9, U4.10, U4.11, U4.12, U4.13, U4.14
/LS4: Q12.4, Q20.3, U5.8, U5.9, U5.10, U5.11, U5.12, U5.13, U5.14
/LS5: Q13.4, Q21.6, U6.8, U6.9, U6.10, U6.11, U6.12, U6.13, U6.14
/LS6: Q14.4, Q21.3, U7.8, U7.9, U7.10, U7.11, U7.12, U7.13, U7.14
/RHI0: P1.10, Q8.1, R22.1
/RHI1: P1.11, Q9.1, R23.1
/RHI2: P1.12, Q10.1, R24.1
/RHI3: P1.13, Q11.1, R25.1
/RHI4: P1.14, Q12.1, R26.1
/RHI5: P1.15, Q13.1, R27.1
/RHI6: P1.16, Q14.1, R28.1
/RLI0: P2.10, Q18.5, R36.1
/RLI1: P2.11, Q19.2, R37.1
/RLI2: P2.12, Q19.5, R38.1
/RLI3: P2.13, Q20.2, R39.1
/RLI4: P2.14, Q20.5, R40.1
/RLI5: P2.15, Q21.2, R41.1
/RLI6: P2.16, Q21.5, R42.1
GND: D8.1, D11.1, D19.1, D35.1, D37.1, D46.1, D48.1, P1.8, P2.8, Q1.5, Q2.5, Q3.5, Q4.5, Q5.5, Q6.5, Q7.5, Q8.5, Q9.5, Q10.5, Q11.5, Q12.5, Q13.5, Q14.5, Q15.1, Q15.4, Q16.1, Q16.4, Q17.1, Q17.4, Q18.1, Q18.4, Q19.1, Q19.4, Q20.1, Q20.4, Q21.1, Q21.4, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2
unnamed: D1.3, U1.1
unnamed: D2.3, U1.2
unnamed: D3.3, U1.3
unnamed: D4.3, U1.4
unnamed: D5.3, U1.5
unnamed: D6.3, U1.6
unnamed: D7.3, U1.7
unnamed: D8.2, D9.1, U2.1
unnamed: D10.3, U2.2
unnamed: D11.2, D42.1, U6.2
unnamed: D12.3, U2.3
unnamed: D13.3, U2.4
unnamed: D14.3, U2.5
unnamed: D15.3, U2.6
unnamed: D16.3, U2.7
unnamed: D17.3, U3.1
unnamed: D18.3, U3.2
unnamed: D19.2, D20.1, U3.3
unnamed: D21.3, U3.4
unnamed: D22.3, U3.5
unnamed: D23.3, U3.6
unnamed: D24.3, U3.7
unnamed: D25.3, U4.1
unnamed: D26.3, U4.2
unnamed: D27.3, U4.3
unnamed: D28.3, U4.4
unnamed: D29.3, U4.5
unnamed: D30.3, U4.6
unnamed: D31.3, U4.7
unnamed: D32.3, U5.1
unnamed: D33.3, U5.2
unnamed: D34.3, U5.3
unnamed: D35.2, D36.1, U5.4
unnamed: D37.2, D38.1, U5.5
unnamed: D39.3, U5.6
unnamed: D40.3, U5.7
unnamed: D41.3, U6.1
unnamed: D43.3, U6.3
unnamed: D44.3, U6.4
unnamed: D45.3, U6.5
unnamed: D46.2, D47.1, U6.6
unnamed: D48.2, D49.1, U6.7
unnamed: D50.3, U7.1
unnamed: D51.3, U7.2
unnamed: D52.3, U7.3
unnamed: D53.3, U7.4
unnamed: D54.3, U7.5
unnamed: D55.3, U7.6
unnamed: D56.3, U7.7
unnamed: Q1.3, Q1.6, R1.2
unnamed: Q2.3, Q2.6, R2.2
unnamed: Q3.3, Q3.6, R3.2
unnamed: Q4.3, Q4.6, R4.2
unnamed: Q5.3, Q5.6, R5.2
unnamed: Q6.3, Q6.6, R6.2
unnamed: Q7.3, Q7.6, R7.2
unnamed: Q8.3, Q8.6, R8.2
unnamed: Q9.3, Q9.6, R9.2
unnamed: Q10.3, Q10.6, R10.2
unnamed: Q11.3, Q11.6, R11.2
unnamed: Q12.3, Q12.6, R12.2
unnamed: Q13.3, Q13.6, R13.2
unnamed: Q14.3, Q14.6, R14.2
VCC: D9.2, D20.2, D36.2, D38.2, D42.2, D47.2, D49.2, P1.9, P2.9, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, Q9.2, Q10.2, Q11.2, Q12.2, Q13.2, Q14.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1

## Commit log

2016-04-24 Initial commit. Rev. 1

Notices in the files:
Flipdot_7x7.kicad_pcb:
License: CC-BY-SA 3.0
FlipDot 2.7\", Rev 1., CC-BY-SA 3.0, twam.info, based on Active Flipper by vagrearg.org
